# Keil uVision project mkp4.uvprojx, settings and files
target mkp4 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MDR32F1QI Milandr
  pack: Milandr.MDR32FxQI.1.1
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: mkp4 +hex
  AfterMake: cmd /c copy .\Obj\*.hex .
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --diag_suppress=47
  c include: .\core\inc;.\core\src;.\PT
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  scatter file: .\RTE\Device\MDR32F1QI\MDR32F1QI.sct
  group core
    ./core/src/: main.c pins.c uart_func.c XTick.c MDR1986VE1T_IT.c MIL1553B_RT.c
    ./core/inc/: typedef.h
software components: Device:Startup 2.1.0i, Drivers:EEPROM 2.1.0i, Drivers:IWDG 2.0.3i, Drivers:MIL_STD_1553 2.0.3i, Drivers:PORT 2.0.3i, Drivers:RST_CLK 2.0.3i, Drivers:TIMER 2.1.0i, Drivers:UART 2.1.0i, Drivers:UTILS 1.0.0i
